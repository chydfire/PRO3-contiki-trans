# Keil uVision project gpio.uvproj, settings and files
target A7139 (MCS-51)
  device: SN8F5708 SONiX
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x3FF5) CLOCK(32000000) MODC2 DPC MDU_R515
  output: gpio +hex
  AfterMake: HexConvert.exe $D "#H"
  c flags: Optimize=8 SizeSpeed=1
  c include: .\source\USER\A7139;.\source\USER\timer;.\source\USER\uart;.\source\USER\led;C:\Keil_v5\C51\INC\SONIX;.\source\USER\clock;.\source\USER\inc;.\source\USER\rtimer;.\source\USER\cmd
  asm include: .\source\STARTUP;.\source\CONFIG
  group STARTUP
    ./source/STARTUP/: STARTUP.A51
  group CONFIG
    ./source/CONFIG/: OPTIONS_SN8F5708.A51
  group USER
    ./source/USER/: main.c
    ./source/USER/A7139/: A7139.c A7139_CONFIG.c A7139_spi.c A7139_comm.c
    ./source/USER/uart/: uart.c
    ./source/USER/led/: led.c
    ./source/USER/cmd/: cmd.c
  group CONTIKI
    ./source/USER/clock/: clock.c
    ./source/USER/rtimer/: rtimer.c rtimer-arch.c
